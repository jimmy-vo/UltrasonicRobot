# Keil uVision project Full_project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Full_project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32F4-Discovery;..\..\digitalclock_[systick];..\KeilC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../: stm32f4xx_it.c main.c Manual.c
  group periph
    ../: system_stm32f4xx.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lis302dl.c
  group sys
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Module
    ../: encoder.c motor.c Realtime_Manage.c Servo.c Bluetooth_HC06.c Ultrasonic_SR04.c acceleration_sensor.c
